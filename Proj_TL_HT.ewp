# IAR project Proj_TL_HT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8E Microchip ATSAM3X8E
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Proj_TL_HT.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\HW-LAbs\Project\Proj_TL_HT.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: alarm.c alarm.h at91sam3x8.h byte_manipulator.c byte_manipulator.h core_cm3.h core_cmFunc.h core_cmInstr.h cstartup.s datelist.c datelist.h display.c display.h exceptions.c exceptions.h key_pad.c key_pad.h light_LED.c light_LED.h light_sensor.c light_sensor.h main.c main.h servo_motor.c servo_motor.h startup_sam3x.c system_sam3x.c system_sam3x.h temperature.c temperature.h time.c time.h timelist.c timelist.h TODO.txt view_menu.c view_menu.h view_records.c view_records.h view_select_date.c view_select_date.h view_temperature_limits.c view_temperature_limits.h
